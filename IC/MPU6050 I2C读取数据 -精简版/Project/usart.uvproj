# Keil uVision project usart.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usart +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Startup;..\USER;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../USER/: main.c stm32f10x_it.c delay.c sys.c MPU6050.c
  group cmsis
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ../Startup/: startup_stm32f10x_hd.s
  group libraries
    ../Libraries/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c
